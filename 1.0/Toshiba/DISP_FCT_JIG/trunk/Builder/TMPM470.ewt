<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>1.Application</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\1.Application\Include\APP_WorkingNormalState.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\1.Application\Include\main.h</name>
      </file>
    </group>
    <group>
      <name>source</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\1.Application\Source\APP_WorkingNormalState.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\1.Application\Source\main.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>2.Component</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Include\Cmp_Display_Service.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Include\Cmp_KeyScan.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Include\Cmp_LQC_Process.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Include\Cmp_Onboarding.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Include\Cmp_SetError.h</name>
      </file>
    </group>
    <group>
      <name>source</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Source\Cmp_Display_Service.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Source\Cmp_KeyScan.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Source\Cmp_LQC_Process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Source\Cmp_Onboarding.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\2.Component\Source\Cmp_SetError.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>3.Library</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Include\general.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Include\Int.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Include\Lib_CommSubMicom.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Include\Lib_EEPROM.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Include\Lib_Flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Include\Lib_UartComm.h</name>
      </file>
    </group>
    <group>
      <name>source</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Source\int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Source\InterruptVectorTable.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Source\Lib_CommSubMicom.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Source\Lib_EEPROM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Source\Lib_Flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\3.Library\Source\Lib_UartComm.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>4.Driver</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\4.Driver\Include\DDI_BootingDriver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\4.Driver\Include\WROS_Register.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\4.Driver\Include\WRRTOS.h</name>
      </file>
    </group>
    <group>
      <name>source</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\4.Driver\Source\DDI_BootingDriver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\4.Driver\Source\WROS_Register.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\4.Driver\Source\WRRTOS.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>5.Hardware</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Include\bootloader.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Include\m470_int.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Include\m470_port.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Include\m470_sio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Include\m470_tmrb.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Include\m470_wdt.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Include\startup.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Include\system.h</name>
      </file>
    </group>
    <group>
      <name>source</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Source\bootloader.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Source\m470_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Source\m470_port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Source\m470_sio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Source\m470_tmrb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Source\m470_wdt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\00.Code\5.Hardware\Source\system.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>6.VariableSource</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\6.VariableSource\Include\Vable_ModelInformation.h</name>
      </file>
    </group>
    <group>
      <name>source</name>
      <file>
        <name>$PROJ_DIR$\..\00.Code\6.VariableSource\Source\Vable_ModelInformation.c</name>
      </file>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\TMPM470FZFG.icf</name>
  </file>
</project>


