# IAR project TMPM470.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM470FDFG Toshiba TMPM470FDFG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.PreInclude: ..\00.Code\3.Library\Include\preinc.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TMPM470.hex
  ILINK.IlinkOutputFile: TMPM470.out
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: TMPM470FZFG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: TMPM470FZFG.icf
  group 1.Application/include
    ../00.Code/1.Application/Include/: APP_WorkingNormalState.h main.h
  group 1.Application/source
    ../00.Code/1.Application/Source/: APP_WorkingNormalState.c main.c
  group 2.Component/include
    ../00.Code/2.Component/Include/: Cmp_Display_Service.h Cmp_KeyScan.h Cmp_LQC_Process.h Cmp_Onboarding.h Cmp_SetError.h
  group 2.Component/source
    ../00.Code/2.Component/Source/: Cmp_Display_Service.c Cmp_KeyScan.c Cmp_LQC_Process.c Cmp_Onboarding.c Cmp_SetError.c
  group 3.Library/include
    ../00.Code/3.Library/Include/: general.h Int.h Lib_CommSubMicom.h Lib_EEPROM.h Lib_Flash.h Lib_UartComm.h
  group 3.Library/source
    ../00.Code/3.Library/Source/: int.c InterruptVectorTable.c Lib_CommSubMicom.c Lib_EEPROM.c Lib_Flash.c Lib_UartComm.c
  group 4.Driver/include
    ../00.Code/4.Driver/Include/: DDI_BootingDriver.h WROS_Register.h WRRTOS.h
  group 4.Driver/source
    ../00.Code/4.Driver/Source/: DDI_BootingDriver.c WROS_Register.c WRRTOS.c
  group 5.Hardware/include
    ../00.Code/5.Hardware/Include/: bootloader.h m470_int.h m470_port.h m470_sio.h m470_tmrb.h m470_wdt.h startup.s system.h
  group 5.Hardware/source
    ../00.Code/5.Hardware/Source/: bootloader.c m470_int.c m470_port.c m470_sio.c m470_tmrb.c m470_wdt.c system.c
  group 6.VariableSource/include
    ../00.Code/6.VariableSource/Include/: Vable_ModelInformation.h
  group 6.VariableSource/source
    ../00.Code/6.VariableSource/Source/: Vable_ModelInformation.c
