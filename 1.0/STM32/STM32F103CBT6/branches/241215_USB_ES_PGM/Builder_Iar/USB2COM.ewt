<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>1_Application</name>
    <file>
      <name>$PROJ_DIR$\..\CODE\1_Application\Source\main.c</name>
    </file>
  </group>
  <group>
    <name>2_Library</name>
    <file>
      <name>$PROJ_DIR$\..\CODE\2_Library\Source\Lib_interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\2_Library\Source\Lib_usart.c</name>
    </file>
  </group>
  <group>
    <name>3_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\hw_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_desc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_endp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_istr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_prop.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_regs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\3_Driver\Source\usb_sil.c</name>
    </file>
  </group>
  <group>
    <name>4_Device</name>
    <file>
      <name>$PROJ_DIR$\..\CODE\4_Device\Source\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\4_Device\Source\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\4_Device\Source\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\4_Device\Source\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\4_Device\Source\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CODE\4_Device\Source\system_stm32f10x.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\startup_stm32f10x_md.s</name>
  </file>
</project>


