# IAR project USB2COM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; IAR_PROJECT
  ICCARM.CCIncludePath2: ..\CODE\1_Application; ..\CODE\2_Library; ..\CODE\3_Driver; ..\CODE\4_Device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; IAR_PROJECT
  OBJCOPY.OOCOutputFile: USB2COM.srec
  ILINK.IlinkOutputFile: USB2COM.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: startup_stm32f10x_md.s
  group 1_Application
    ../CODE/1_Application/Source/: main.c
  group 2_Library
    ../CODE/2_Library/Source/: Lib_interrupt.c Lib_usart.c
  group 3_Driver
    ../CODE/3_Driver/Source/: hw_config.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c
  group 4_Device
    ../CODE/4_Device/Source/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c system_stm32f10x.c
